# Keil uVision project BMS_SH3673520.uvprojx, settings and files
target FD_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00004FE0) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FD_Release
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Lib;..\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\Source;..\Source\conf;..\Source\easylogger\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004800 size 0x9800
  memory RVCT9: RAM 0x20000000 size 0x4fe0
  link misc: --inline --tailreorder
  group Source
    ../Source/: DataDeal.c Fault.c Flash.c LowPowerSleep.c main.c MosStartup.c PubFunc.c RTC.c Runtime.c StartupDefaultHandler.c Sci_Upper.c SleepDeal.c SOC.c System_Init.c System_Monitor.c ProductionID.c Can_HDX.c CanFeidaoFrames.c LogRecord.c SocEnhance.c rtc_sleep.c rtc_sleep_port.c
  group Drivers
    ../STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
    ../Source/: startup_stm32f103xb.s
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../STM32F10x_StdPeriph_Lib_V3.5.0/inc/: misc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group conf
    ../Source/conf/: conf.c conf.h Project_Config.h Project_BuildGuard.h conf_gpio.h
  group SH3673520
    ../Source/afe3520/: Afe3520.c Afe3520App.c BmsProtection3520.c Afe3520.h Afe3520App.h Afe3520Config.h BmsProtection3520.h
    ../Source/: BmsParameters.c BmsParameters.h rtc_sleep_afe3520.c
target FD_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FD_Debug
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,PROJECT_CFG_BUILD_PROFILE=1,PROJECT_CFG_DEBUG_WATCH_ENABLE=1,PROJECT_CFG_DEBUG_MONITOR_ENABLE=1,PROJECT_CFG_IRQ_DEBUG_ENABLE=1,PROJECT_CFG_IRQ_DEBUG_EVENT_ENABLE=0,_DEBUG_
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004800 size 0x9800
  memory RVCT9: RAM 0x20000000 size 0x4fe0
  link misc: --inline --tailreorder
