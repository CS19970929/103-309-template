# Keil uVision project UPG_F103C8.uvprojx, settings and files
target UPG_F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UPG_F103C8
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\stm32f103c8;..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  asm misc: --pd "__MICROLIB SETA 1"
  library: MicroLIB
  memory RVCT4: ROM 0x8004800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\stm32f103c8\UPG_F103C8.sct
  group Startup
    ../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: startup_stm32f10x_hd.s
  group Board
    ../stm32f103c8/: board_main.c board_can.c board_uart.c board_system_stm32f10x.c board_stm32f10x_it.c
  group Core
    ../core/: upg_core.c upg_crc16.c upg_feidao.c upg_params.c upg_serial.c upg_utils.c
  group StdPeriph
    ../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
