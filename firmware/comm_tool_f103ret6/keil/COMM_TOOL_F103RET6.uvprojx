# Keil uVision project COMM_TOOL_F103RET6.uvprojx, settings and files
target COMM_TOOL_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: COMM_TOOL_Debug +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,COMM_TOOL_DEBUG
  c include: ..\source;..\source\bsp;..\source\protocol;..\source\storage;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../source/: main.c
  group BSP
    ../source/bsp/: board.c board_uart.c board_can.c stm32f10x_it.c
  group Protocol
    ../source/protocol/: serial_proto.c can_gateway.c upgrade_manager.c crc16.c
  group Storage
    ../source/storage/: flash_store.c
  group CMSIS
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: startup_stm32f10x_hd.s core_cm3.c
    ../source/bsp/: system_stm32f10x.c
  group StdPeriph
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
target COMM_TOOL_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: COMM_TOOL_Release +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,COMM_TOOL_RELEASE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
