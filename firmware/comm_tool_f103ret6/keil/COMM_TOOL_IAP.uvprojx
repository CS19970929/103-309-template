# Keil uVision project COMM_TOOL_IAP.uvprojx, settings and files
target COMM_TOOL_IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xFFE0) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COMM_TOOL_IAP +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\source;..\source\bsp;..\source\app;..\..\..\..\firmware\comm_tool_f103ret6\source;..\..\..\..\firmware\comm_tool_f103ret6\source\bsp;..\..\..\..\firmware\comm_tool_f103ret6\source\app;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\source\iap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xffe0
  group IAP
    ../source/iap/: ct_iap_main.c ct_iap.c
    ../source/bsp/: ct_watchdog.c
    ../source/: stm32f10x_it.c
  group CMSIS
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
    ../source/: startup_default_handler.c
  group StdPeriph
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Headers
    ../source/iap/: ct_iap.h
    ../source/app/: ct_config.h
    ../source/bsp/: ct_watchdog.h
    ../source/: stm32f10x_it.h
