# Keil uVision project BMS_CAN_IAP_F103C8.uvprojx, settings and files
target BMS_CAN_IAP_F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x4FE0) IROM(0x08000000,0x4800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BMS_CAN_IAP_F103C8 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\source\iap;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\..\..\103 + 309\Project\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x4fe0
  group IAP
    ../source/iap/: bms_iap_main.c bms_iap.c
  group CMSIS
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: startup_stm32f10x_hd.s core_cm3.c
    ../source/iap/: system_stm32f10x_iap.c
  group StdPeriph
    ../../../103 + 309/Project/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c
  group Headers
    ../source/iap/: bms_iap.h bms_iap_config.h
